# Keil uVision project v_0.2_STM32F103_SIM800L_LCD_PHONE_12.11.2017.uvprojx, settings and files
target v_0.2_Phone+FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: v_0.2_STM32F103_SIM800L_LCD_PHONE_12.11.2017
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport;.\FreeRTOS;.\FreeRTOS\include;.\LCD5110 (Driver AVR to STM);.\STM32F10x_StdPeriph_Driver\src;.\STM32F10x_StdPeriph_Driver\inc;.\Wi-Fi_ESP8266;.\Main;.\GSM_SIM800L;.\UART;.\Visualization;.\STM32F10x_StdPeriph_Driver\STM32F10x_StdPeriph_Template;.\Functions;.\Tasks;.\CPU-Init;.\GPS_SIM28ML
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Main
    ./Main/: main.c
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_1.c list.c port.c queue.c tasks.c timers.c
  group LCD_Driver
    ./LCD5110 (Driver AVR to STM)/: n3310.c
  group Tasks
    ./Tasks/: tasks.c
  group SPL_Library
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_bkp.c
  group Visualization
    ./Visualization/: visualization.c
  group Wi-Fi_ESP8266
    ./Wi-Fi_ESP8266/: wi-fi_esp8266.c
  group UART
    ./UART/: uart.c
  group GSM_SIM800L
    ./GSM_SIM800L/: gsm_sim800l.c
  group Functions
    ./Functions/: functions.c
  group System_Config
    ./CPU-Init/: cpu_init.c
  group GPS_SIM28ML
    ./GPS_SIM28ML/: gps_sim28ml.c
